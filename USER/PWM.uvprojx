# Keil uVision project PWM.uvprojx, settings and files
target PWM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\IIC;..\HARDWARE\motor_control;..\HARDWARE\KALMAN;..\HARDWARE\parameter_identify;..\HARDWARE\filter;..\HARDWARE\flux_observer;..\HARDWARE\NeuralPID;..\HARDWARE\SMO;..\HARDWARE\DMA;..\HARDWARE\IQmath
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c configure.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IIC/: ina219.c ina3221.c ina3221_2.c
    ../HARDWARE/motor_control/: park.c
    ../HARDWARE/filter/: filter.c filter_data.c
    ../HARDWARE/parameter_identify/: parameter_identify.c parameter_identify_data.c
    ../HARDWARE/flux_observer/: FluxObserver.c rt_nonfinite.c rtGetInf.c rtGetNaN.c
    ../HARDWARE/SMO/: SMO.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/IQmath/: IQmathLib-cm3.lib
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c stack.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c
  group README
    ../: README.TXT
